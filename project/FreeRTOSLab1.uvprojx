# Keil uVision project FreeRTOSLab1.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOSLab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\maraw\OneDrive\Desktop\project\FreeRTOS_Lab1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c tm4c123gh6pm_.h UART.h UART.c lighting_task.c shared_state.h init.c init.h lighting_task.h led_builtin.c led_builtin.h lighting_hal.c lighting_hal.h shared_state.c uart_drain_task.c uart_drain_task.h oven_task.c oven_task.h UART_task.c UART_task.h
  group driverlib
    ./driverlib/: adc.c adc.h cpu.c cpu.h gpio.c gpio.h interrupt.c interrupt.h sysctl.c sysctl.h systick.c systick.h
software components: CMSIS:CORE 6.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, Device:Startup 1.0.1
